Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-04-23T01:55:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 23 01:55:25 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{B62B2AD2-AE85-4182-836F-FFB1AF323B47}\ifc * Database version: 5507 * Database creation date: Fri Apr 23 01:55:24 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 23 01:55:25 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 23 01:55:25 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 11XI8605_CDN_11667170_WXI860WCS_LW, 11667170_CDN_WXI860WCS_LW:11XI8605_CDN_11667170_WXI860WCS_LW:211732
In: Level 1
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Orange, z_Miele_Design_Powder Coat_Lotus White, z_Miele_Design_Glass, z_Miele_Design_Glass Black, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - Reference: 11XI8605_CDN_11667170_WXI860WCS_LW
Pset_ManufacturerTypeInformation - Manufacturer: Miele
